# SPDX-License-Identifier: MIT
# Keep test vectors at the same version as cryptography
PV = "49.0.0"
SRC_URI[sha256sum] = "9e3352b1e652d2f986755edf79228a385f6b0bd53d5b248c087ff79b24a7b516"

# This release already accepts Wrynose's uv-build version
SRC_URI = ""
